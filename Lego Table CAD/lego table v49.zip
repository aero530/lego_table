# Autodesk Inventor part: back
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-09
Part Number: back
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: back
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
